# Keil uVision project k26f_if.uvproj, settings and files
target k26f_if (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: k26f_if
  BeforeMake: ..\..\..\tools\pre_build_script.bat
  AfterMake: ..\..\..\tools\post_build_script.bat $L@L $KARM
  c flags: Optim=3 OneElfS=1
  c define: DAPLINK_VERSION=254, HID_ENDPOINT, MSC_ENDPOINT, CDC_ENDPOINT, WEBUSB_INTERFACE, WINUSB_INTERFACE, DRAG_N_DROP_SUPPORT, DAPLINK_IF, DAPLINK_BUILD_KEY=0x9B939E8F, OS_TICK=10000, INTERFACE_K26F, CPU_MK26FN2M0VMD18, DAPLINK_HIC_ID=0x97969909, FLASH_SSD_CONFIG_ENABLE_FLEXNVM_SUPPORT=0, FLASH_DRIVER_IS_FLASH_RESIDENT=1, OS_CLOCK=120000000, BULK_ENDPOINT
  c misc: --gnu --c99 --no_unaligned_access --diag_suppress=66 --no_unaligned_access
  c include: ..\..\..\source\usb; ..\..\..\source\daplink\cmsis-dap; ..\..\..\source\daplink\drag-n-drop; ..\..\..\source\daplink\usb2uart; ..\..\..\source\daplink\settings; ..\..\..\source\daplink; ..\..\..\source\daplink\interface; ..\..\..\source\cmsis-core; ..\..\..\source\hic_hal; ..\..\..\source\target; ..\..\..\source\rtos; ..\..\..\source\hic_hal\freescale\k26f; ..\..\..\source\hic_hal\freescale\k26f\MK26F18; ..\..\..\source\hic_hal\freescale\iap; ..\..\..\projectfiles\uvision\k26f_bl
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=254,-DHID_ENDPOINT,-DMSC_ENDPOINT,-DCDC_ENDPOINT,-DWEBUSB_INTERFACE,-DWINUSB_INTERFACE,-DDRAG_N_DROP_SUPPORT,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DOS_TICK=10000,-DINTERFACE_K26F,-DCPU_MK26FN2M0VMD18,-DDAPLINK_HIC_ID=0x97969909,-DFLASH_SSD_CONFIG_ENABLE_FLEXNVM_SUPPORT=0,-DFLASH_DRIVER_IS_FLASH_RESIDENT=1,-DOS_CLOCK=120000000,-DBULK_ENDPOINT --no_unaligned_access
  scatter file: ..\..\..\source\daplink\daplink.sct
  link misc: --predefine="-DDAPLINK_IF" --predefine="-I..\..\..\source\hic_hal\freescale\k26f"
  group cmsis-dap
    ../../../source/daplink/cmsis-dap/: DAP.c DAP_queue.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
  group daplink_if
    ../../../source/daplink/interface/: bootloader_update.c daplink.c main.c SVC_Table.s swd_host.c swd_host_ca.c target_flash.c
    ../../../source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
  group default
    ../../../source/hic_hal/: board.h flash_blob.h flash_hal.h FlashOS.h FlashPrg.h gpio.h read_uid.h sdk.h uart.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h error.h info.h macro.h util.h validation.h
    ../../../source/rtos/: cmsis_os2.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h RTL.h RTX_Config.h
    ../../../source/cmsis-core/: core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../source/daplink/cmsis-dap/: DAP.h DAP_queue.h debug_ca.h debug_cm.h
    ../../../source/hic_hal/freescale/k26f/: DAP_config.h daplink_addr.h Driver_Common.h Driver_USART.h fsl_dmamux.h fsl_edma.h fsl_smc.h fsl_uart.h fsl_uart_cmsis.h fsl_uart_edma.h fsl_usb.h hic_init.h IO_Config.h RTE_Device.h usb_buf.h usb_phy.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h virtual_fs.h
    ../../../source/hic_hal/freescale/k26f/MK26F18/: fsl_clock.h fsl_device_registers.h MK26F18.h MK26F18_features.h system_MK26F18.h
    ../../../source/hic_hal/freescale/iap/: fsl_common.h fsl_flash.h
    ../../../source/daplink/interface/: main.h swd_host.h tasks.h
    ../../../source/usb/: rl_usb.h usb.h usb_bulk.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/daplink/settings/: settings.h
    ../../../source/target/: target_board.h target_board.h target_config.h target_config.h target_family.h target_family.h target_reset.h target_reset.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group family
    ../../../source/family/freescale/: target_reset_Kseries.c target_reset_Lseries.c target_reset_mimxrt.c target_reset_rapid_iot.c
    ../../../source/family/nordic/: target_reset_nrf51.c target_reset_nrf52.c
    ../../../source/family/realtek/: target_reset_realtek_rtl8195am.c
    ../../../source/family/renesas/: target_reset_rza.c
    ../../../source/family/ti/: target_reset_ti.c
    ../../../source/family/toshiba/: target_reset_tz.c
    ../../../source/family/wiznet/: target_reset_wiznet.c
  group fsl_flash_driver
    ../../../source/hic_hal/freescale/iap/: FlashDev.c FlashPrg.c fsl_flash.c
  group hic_hal
    ../../../source/hic_hal/freescale/k26f/MK26F18/: fsl_clock.c system_MK26F18.c
    ../../../source/hic_hal/freescale/k26f/: fsl_dmamux.c fsl_edma.c fsl_smc.c fsl_uart.c fsl_uart_cmsis.c fsl_uart_edma.c gpio.c hic_init.c read_uid.c uart.c usb_config.c usb_phy.c usbd_MK26F.c
    ../../../source/hic_hal/freescale/k26f/armcc/: startup_MK26F18.s
  group rtos
    ../../../source/rtos/: cmsis_os2_port.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c RTX_Config.c
    ../../../source/rtos/cm4/: HAL_CM4.c
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom.c
  group target
    ../../../source/target/: target_board.c target_family.c
  group usb
    ../../../source/usb/bulk/: usbd_bulk.c
    ../../../source/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/hid/: usbd_core_hid.c usbd_hid.c usbd_user_hid.c
    ../../../source/usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../source/usb/webusb/: usbd_core_webusb.c
    ../../../source/usb/winusb/: usbd_core_winusb.c
  group usb2uart
    ../../../source/daplink/usb2uart/: usbd_user_cdc_acm.c
