# Keil uVision project max32625_bl.uvproj, settings and files
target max32625_bl (ARM-ADS)
  device: MAX32625 Maxim Integrated
  cpu: IRAM(0x20000000, 0x28000) IROM(0, 0x80000) CLOCK(96000000) CPUTYPE("Cortex-M4.fp.sp")
  output: max32625_bl
  BeforeMake: ..\..\..\tools\pre_build_script.bat
  AfterMake: ..\..\..\tools\post_build_script.bat $L@L $KARM
  c flags: Optim=3 OneElfS=1
  c define: DAPLINK_VERSION=254, MSC_ENDPOINT, DAPLINK_BL, DAPLINK_BUILD_KEY=0x9B939D93, DRAG_N_DROP_SUPPORT, OS_TICK=10000, INTERFACE_MAX32625, DAPLINK_HIC_ID=0x97969906, OS_CLOCK=96000000
  c misc: --gnu --c99
  c include: ..\..\..\source\usb; ..\..\..\source\daplink; ..\..\..\source\daplink\bootloader; ..\..\..\source\cmsis-core; ..\..\..\source\hic_hal; ..\..\..\source\daplink\drag-n-drop; ..\..\..\source\daplink\settings; ..\..\..\source\target; ..\..\..\source\rtos_none; ..\..\..\source\hic_hal\maxim\max32625
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=254,-DMSC_ENDPOINT,-DDAPLINK_BL,-DDAPLINK_BUILD_KEY=0x9B939D93,-DDRAG_N_DROP_SUPPORT,-DOS_TICK=10000,-DINTERFACE_MAX32625,-DDAPLINK_HIC_ID=0x97969906,-DOS_CLOCK=96000000
  scatter file: ..\..\..\source\daplink\daplink.sct
  link misc: --predefine="-DDAPLINK_BL" --predefine="-I..\..\..\source\hic_hal\maxim\max32625"
  group board
    ../../../source/board/: max32625_bl.c
  group daplink_bl
    ../../../source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
    ../../../source/daplink/bootloader/: daplink.c main.c SVC_Table.s
  group default
    ../../../source/hic_hal/maxim/max32625/: adc_regs.h clkman_regs.h DAP_config.h daplink_addr.h flc_regs.h gpio_regs.h icc_regs.h IO_Config.h ioman_regs.h max32625.h owm_regs.h pwrman_regs.h pwrseq_regs.h rtc_regs.h system_max32625.h tmr_regs.h trim_regs.h uart_regs.h usb_buf.h usb_regs.h
    ../../../source/hic_hal/: board.h flash_blob.h flash_hal.h FlashOS.h FlashPrg.h gpio.h read_uid.h sdk.h uart.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h error.h info.h macro.h util.h validation.h
    ../../../source/rtos_none/: cmsis_os2.h SysTick_Handler.h
    ../../../source/cmsis-core/: core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h virtual_fs.h
    ../../../source/daplink/bootloader/: main.h
    ../../../source/usb/: rl_usb.h usb.h usb_bulk.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/daplink/settings/: settings.h
    ../../../source/target/: target_board.h target_config.h target_family.h target_reset.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group hic_hal
    ../../../source/hic_hal/maxim/max32625/: FlashPrg.c gpio.c read_uid.c system_max32625.c uart.c usb_config.c usbd_max32625.c
    ../../../source/hic_hal/maxim/max32625/armcc/: startup_MAX32625.S
  group rtos
    ../../../source/rtos_none/: cmsis_os2_port.c SysTick_Handler.c
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom_stub.c
  group target
    ../../../source/target/: target_board.c
  group usb
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/msc/: usbd_core_msc.c usbd_msc.c
