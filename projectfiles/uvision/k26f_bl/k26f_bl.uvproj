# Keil uVision project k26f_bl.uvproj, settings and files
target k26f_bl (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: k26f_bl
  BeforeMake: ..\..\..\tools\pre_build_script.bat
  AfterMake: ..\..\..\tools\post_build_script.bat $L@L $KARM
  c flags: Optim=3 OneElfS=1
  c define: DAPLINK_VERSION=254, MSC_ENDPOINT, DAPLINK_BL, DAPLINK_BUILD_KEY=0x9B939D93, DRAG_N_DROP_SUPPORT, OS_TICK=10000, INTERFACE_K26F, CPU_MK26FN2M0VMD18, DAPLINK_HIC_ID=0x97969909, FLASH_SSD_CONFIG_ENABLE_FLEXNVM_SUPPORT=0, FLASH_DRIVER_IS_FLASH_RESIDENT=1, OS_CLOCK=120000000
  c misc: --gnu --c99 --no_unaligned_access --diag_suppress=66 --no_unaligned_access
  c include: ..\..\..\source\usb; ..\..\..\source\daplink; ..\..\..\source\daplink\bootloader; ..\..\..\source\cmsis-core; ..\..\..\source\hic_hal; ..\..\..\source\daplink\drag-n-drop; ..\..\..\source\daplink\settings; ..\..\..\source\target; ..\..\..\source\rtos_none; ..\..\..\source\hic_hal\freescale\k26f; ..\..\..\source\hic_hal\freescale\k26f\MK26F18; ..\..\..\source\hic_hal\freescale\iap; ..\..\..\projectfiles\uvision\k26f_bl
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=254,-DMSC_ENDPOINT,-DDAPLINK_BL,-DDAPLINK_BUILD_KEY=0x9B939D93,-DDRAG_N_DROP_SUPPORT,-DOS_TICK=10000,-DINTERFACE_K26F,-DCPU_MK26FN2M0VMD18,-DDAPLINK_HIC_ID=0x97969909,-DFLASH_SSD_CONFIG_ENABLE_FLEXNVM_SUPPORT=0,-DFLASH_DRIVER_IS_FLASH_RESIDENT=1,-DOS_CLOCK=120000000 --no_unaligned_access
  scatter file: ..\..\..\source\daplink\daplink.sct
  link misc: --predefine="-DDAPLINK_BL" --predefine="-I..\..\..\source\hic_hal\freescale\k26f"
  group board
    ../../../source/board/: k26f_bl.c
  group daplink_bl
    ../../../source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
    ../../../source/daplink/bootloader/: daplink.c main.c SVC_Table.s
  group default
    ../../../source/hic_hal/: board.h flash_blob.h flash_hal.h FlashOS.h FlashPrg.h gpio.h read_uid.h sdk.h uart.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h error.h info.h macro.h util.h validation.h
    ../../../source/rtos_none/: cmsis_os2.h SysTick_Handler.h
    ../../../source/cmsis-core/: core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../source/hic_hal/freescale/k26f/: DAP_config.h daplink_addr.h Driver_Common.h Driver_USART.h fsl_dmamux.h fsl_edma.h fsl_smc.h fsl_uart.h fsl_uart_cmsis.h fsl_uart_edma.h fsl_usb.h hic_init.h IO_Config.h RTE_Device.h usb_buf.h usb_phy.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h virtual_fs.h
    ../../../source/hic_hal/freescale/k26f/MK26F18/: fsl_clock.h fsl_device_registers.h MK26F18.h MK26F18_features.h system_MK26F18.h
    ../../../source/hic_hal/freescale/iap/: fsl_common.h fsl_flash.h
    ../../../source/daplink/bootloader/: main.h
    ../../../source/usb/: rl_usb.h usb.h usb_bulk.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/daplink/settings/: settings.h
    ../../../source/target/: target_board.h target_config.h target_family.h target_reset.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group fsl_flash_driver
    ../../../source/hic_hal/freescale/iap/: FlashDev.c FlashPrg.c fsl_flash.c
  group hic_hal
    ../../../source/hic_hal/freescale/k26f/MK26F18/: fsl_clock.c system_MK26F18.c
    ../../../source/hic_hal/freescale/k26f/: fsl_dmamux.c fsl_edma.c fsl_smc.c fsl_uart.c fsl_uart_cmsis.c fsl_uart_edma.c gpio.c hic_init.c read_uid.c uart.c usb_config.c usb_phy.c usbd_MK26F.c
    ../../../source/hic_hal/freescale/k26f/armcc/: startup_MK26F18.s
  group rtos
    ../../../source/rtos_none/: cmsis_os2_port.c SysTick_Handler.c
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom_stub.c
  group target
    ../../../source/target/: target_board.c
  group usb
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/msc/: usbd_core_msc.c usbd_msc.c
